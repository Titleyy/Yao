# Keil uVision project FOC.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: TLE9879QXA40 Infineon
  pack: Infineon.TLE987x_DFP.1.6.0
  cpu: IRAM(0x18000018,0x17E8) IRAM2(0x18000000,0x10) IROM(0x11000000,0x1EFFC) IROM2(0x1101EFFC,0x1004) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FOC
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c misc: -Wno-switch
  c include: .\Example\cfg;.\Example\include;.\FRW\include;.\MHA\include;.\Math\include;.\MCTRL\include;.\MS\include;.\CHA\include;.\FHA\include;.\DTI\include;.\Cfg
  library: MicroLIB
  memory RVCT4: ROM 0x11000000 size 0x1effc
  memory RVCT5: ROM 0x1101effc size 0x1004
  memory RVCT9: RAM 0x18000018 size 0x17e8
  memory RVCT10: RAM 0x18000000 size 0x10
  scatter file: .\Linker\linker_arm_ram_high.sct
  link misc: --diag_suppress=9931
  group Example
    ./Example/src/: ComApp.c ident.c main.c SignalList.c MctrlExample.c
  group Cfg
    ./Cfg/: Ifx_MAS_Modulator_F16_Cfg.c Ifx_MDA_FluxEstimator_F16_Cfg.c Ifx_MDA_FocController_F16_Cfg.c Ifx_MDA_IToFController_F16_Cfg.c Ifx_MDA_VToFController_F16_Cfg.c Ifx_MS_FocSolution_F16_Cfg.c MctrlExample_Cfg.c Ifx_FRW_ParamTable_Cfg.c
  group FRW
    ./FRW/src/: Ifx_FRW_ParamTable.c
  group MAS
    ./MCTRL/src/: Ifx_MAS_Modulator_F16.c Ifx_MAS_Modulator_F16_tableSin60Sqrt3.c
  group Math
    ./Math/src/: Ifx_Common.c Ifx_Math_AccelLimit_F16.c Ifx_Math_AdvancedMath_F16.c Ifx_Math_Arithmetic_F16.c Ifx_Math_Atan2.c Ifx_Math_CartToPolar.c Ifx_Math_Clarke.c Ifx_Math_CurrentReconstruction.c Ifx_Math_Interp1DLut.c Ifx_Math_InvClarke.c Ifx_Math_InvPark.c Ifx_Math_LowPass1st_F16.c Ifx_Math_Lut_Atan_F16_Table.c Ifx_Math_Lut_CartToPolar_F16_Table.c Ifx_Math_Lut_DivShL_F32_Table.c Ifx_Math_Lut_SinCos_F16_Table.c Ifx_Math_MotorControl_F16.c Ifx_Math_Park.c Ifx_Math_Pi_F16.c Ifx_Math_PLL_F16.c Ifx_Math_PolarToCart.c Ifx_Math_RateLimit_F16.c Ifx_Math_SpeedPreControl_F16.c Ifx_Math_Trigonometric_F16.c
  group MDA
    ./MCTRL/src/: Ifx_MDA_FluxEstimator_F16.c Ifx_MDA_FocController_F16.c Ifx_MDA_IToFController_F16.c Ifx_MDA_StartAngleIdent_F16.c Ifx_MDA_VToFController_F16.c
  group MHA
    ./MHA/src/: Ifx_MHA_BridgeDrv_F16_TLE987.c Ifx_MHA_MeasurementADC_F16_TLE987.c Ifx_MHA_PatternGen_F16_TLE987.c Ifx_MHA_DriverGroup_F16.c
  group MS
    ./MCTRL/src/: Ifx_MS_FocSolution_F16.c
  group CHA
    ./CHA/src/: Ifx_CHA_DTI_TLE987.c
  group FHA
    ./FHA/src/: Ifx_FHA_TbStreaming_TLE987.c
  group DTI
    ./DTI/lib/: arbiter.c eventService.c linklayer.c messageHandler.c parameterService.c router.c samplingService.c sdoService.c streamingService.c targetInterface.c traceHandler.c
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:BF-Stepping 0.0.1, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.3.0, Device:SDK:ADC2 0.2.6, Device:SDK:BDRV 0.6.1, Device:SDK:BOOTROM 0.3.3, Device:SDK:CCU6 0.4.1, Device:SDK:CSA 0.1.9, Device:SDK:DMA 0.2.2, Device:SDK:GPT12E 0.2.2, Device:SDK:INT 0.2.3, Device:SDK:ISR 0.2.9, Device:SDK:LIN 0.2.0, Device:SDK:MON 0.1.7, Device:SDK:PMU 0.2.2, Device:SDK:PORT 0.6.0, Device:SDK:SCU 0.5.7, Device:SDK:SSC 0.1.8, Device:SDK:TIMER2x 0.2.3, Device:SDK:TIMER3 0.2.0, Device:SDK:UART 0.2.4, Device:SDK:WDT1 0.3.3, Device:Startup 1.2.0
